# Keil uVision project template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group init
    ./: FS_CM3.lib STM32_Init.c STM32_Init.h STM32F10x.s STM32F10xR.LIB
  group main
    ./: main.c
    ./systemInit/: SystemInit.c SystemInit.h
  group serial
    ./serial/: serial.c serial.h
  group delay
    ./delay/: delay.c delay.h
  group CRC
    ./CRC/: lib_crc.c lib_crc.h
  group adc
    ./adc/: adc.c adc.h
  group eeprom
    ./eeprom/: eeprom.c eeprom.h memory.c memory.h
  group SSD1306
    ./SSD1306/: font5x7.h font7x10.h SSD1306.c SSD1306.h
